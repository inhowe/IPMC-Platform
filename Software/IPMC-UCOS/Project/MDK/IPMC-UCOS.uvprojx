# Keil uVision project IPMC-UCOS.uvprojx, settings and files
target IPMC-UCOS (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IPMC +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F405xx,__TARGET_FPU_VFP,__FPU_PRESENT=1,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c include: ..\..\USER;..\..\SYSTEM;..\..\HARDWARE;..\..\Driver\STM32F4xx_HAL_Driver\Inc;..\..\Driver\CMSIS;..\..\UCOSII\uC-LIB;..\..\UCOSII\uC-CPU;..\..\UCOSII\UCOS_BSP;..\..\UCOSII\uCOS-CONFIG;..\..\UCOSII\uCOS-II\Source;..\..\UCOSII\uC-CPU\ARM-Cortex-M4\RealView;..\..\UCOSII\uC-LIB\Ports\ARM-Cortex-M4\RealView;..\..\UCOSII\uCOS-II\Ports\ARM-Cortex-M4\Generic\RealView;.\Output
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ../../USER/: main.c protocol.c queue.c stm32f4xx_it.c system_stm32f4xx.c task.c wave.c algorithm.c ipmc.c
  group HARDWARE
    ../../HARDWARE/: AD5722.c ADS1115.c key.c led.c laser.c SHT2x.c
  group SYSTEM
    ../../SYSTEM/: can.c delay.c myiic.c sys.c usart.c dma.c iwdg.c flash.c
  group HALLIB
    ../../Driver/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_iwdg.c
  group CMSIS
    ../../Driver/CMSIS/: startup_stm32f429xx.s
    ../../Driver/DSP_Lib/: arm_cortexM4lf_math.lib
  group UCOSII_CONFIG
    ../../UCOSII/uCOS-CONFIG/: app_cfg.h app_hooks.c cpu_cfg.h includes.h lib_cfg.h os_cfg.h
  group UCOSII_BSP
    ../../UCOSII/UCOS_BSP/: bsp.c cpu_bsp.c
  group UCOSII_CPU
    ../../UCOSII/uC-CPU/: cpu_core.c
    ../../UCOSII/uC-CPU/ARM-Cortex-M4/RealView/: cpu_a.asm cpu_c.c
  group UCOSII_LIB
    ../../UCOSII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../UCOSII/uC-LIB/Ports/ARM-Cortex-M4/RealView/: lib_mem_a.asm
  group UCOSII_SOURCE
    ../../UCOSII/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII_PORT
    ../../UCOSII/uCOS-II/Ports/ARM-Cortex-M4/Generic/RealView/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c
