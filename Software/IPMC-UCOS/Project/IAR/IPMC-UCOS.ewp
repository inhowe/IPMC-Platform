# IAR project IPMC-UCOS.ewp, settings and files
configuration IPMC_Platform (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F405xx
  ICCARM.CCIncludePath2: ..\..\Driver\CMSIS; ..\..\Driver\STM32F4xx_HAL_Driver\Inc; ..\..\HARDWARE; ..\..\SYSTEM; ..\..\USER; ..\..\UCOSII\uC-CPU; ..\..\UCOSII\uC-CPU\ARM-Cortex-M4\IAR; ..\..\UCOSII\uC-LIB; ..\..\UCOSII\UCOS_BSP; ..\..\UCOSII\uCOS-CONFIG; ..\..\UCOSII\uCOS-II\Ports\ARM-Cortex-M4\Generic\IAR; ..\..\UCOSII\uCOS-II\Source
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IPMC-UCOS.srec
  ILINK.IlinkOutputFile: IPMC-UCOS.out
  ILINK.IlinkIcfFile: stm32f405xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/Hardware
    ../../HARDWARE/: AD5722.c ADS1115.c key.c laser.c led.c
  group Application/System
    ../../SYSTEM/: can.c delay.c myiic.c sys.c usart.c
  group Application/User
    ../../USER/: main.c protocol.c queue.c stm32f4xx_it.c system_stm32f4xx.c task.c wave.c
  group Drivers/CMSIS
    ../../Driver/CMSIS/: startup_stm32f40xx.s
  group Drivers/STM32F4xx_HAL_Driver
    ../../Driver/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group UCOS/uC-BSP
    ../../UCOSII/UCOS_BSP/: bsp.c cpu_bsp.c
  group UCOS/uC-CFG
    ../../UCOSII/uCOS-CONFIG/: app_cfg.h app_hooks.c cpu_cfg.h includes.h lib_cfg.h os_cfg.h
  group UCOS/uC-CPU
    ../../UCOSII/uC-CPU/ARM-Cortex-M4/IAR/: cpu_a.asm cpu_c.c
    ../../UCOSII/uC-CPU/: cpu_core.c
  group UCOS/uC-LIB
    ../../UCOSII/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
    ../../UCOSII/uC-LIB/Ports/ARM-Cortex-M4/IAR/: lib_mem_a.asm
  group UCOS/uCOS-II/Ports
    ../../UCOSII/uCOS-II/Ports/ARM-Cortex-M4/Generic/IAR/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group UCOS/uCOS-II/Source
    ../../UCOSII/uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
