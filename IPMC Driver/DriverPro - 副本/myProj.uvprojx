# Keil uVision project myProj.uvprojx, settings and files
target myProj (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: myProj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F40_41xxx
  c include: .\CMSIS\Include;.\CMSIS\DSP_Lib\Source\BasicMathFunctions;.\CMSIS\DSP_Lib\Source\CommonTables;.\CMSIS\DSP_Lib\Source\ComplexMathFunctions;.\CMSIS\DSP_Lib\Source\ControllerFunctions;.\CMSIS\DSP_Lib\Source\FastMathFunctions;.\CMSIS\DSP_Lib\Source\FilteringFunctions;.\CMSIS\DSP_Lib\Source\MatrixFunctions;.\CMSIS\DSP_Lib\Source\StatisticsFunctions;.\CMSIS\DSP_Lib\Source\SupportFunctions;.\CMSIS\DSP_Lib\Source\TransformFunctions;.\STM32F4xx_StdPeriph_Driver\src;.\STM32F4xx_StdPeriph_Driver\inc;.\user
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group boot
    ./boot/: startup_stm32f40_41xxx.s startup_stm32f40xx.s startup_stm32f405xx.s startup_stm32f469_479xx.s
  group user
    ./user/: main.c stm32f4xx_it.c system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ./STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Devices
    ./user/: eeprom.c delay.c dev.c tlv5608.c
